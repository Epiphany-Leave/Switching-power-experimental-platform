# Keil uVision project Project.uvprojx, settings and files
target stm32f334 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: yyds +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F334x8,__TARGET_FPU_VFP,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\api;..\cm4_core;..\fwlib\inc;..\driver;..\main;..\alg;..\api\OLED;..\measure;..\cntl_lib_yyds
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group main
    ../main/: main.c stm32f3xx_it.c system_stm32f30x.c ELAB_subsystem.c KEY_ELAB.c
  group cntl_lib_yyds
    ../cntl_lib_yyds/: my_board.c my_board.h pid_yyds.c pid_yyds.h SVPWM_CTR.c SVPWM_CTR.h arm_cortexM4lf_math.lib
  group api
    ../api/OLED/: oled.c
  group driver
    ../driver/: dr_led.c key.c
  group fwlib
    ../fwlib/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group cm4_core
    ../cm4_core/: startup_stm32f334x8.s
  group MEASURE
    ../measure/: power_meas_sine_analyzer.c spll_1ph_sogi.c
